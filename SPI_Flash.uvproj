# Keil uVision project SPI_Flash.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C1233H6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: SPI_Flash
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./src/: flash.c gpio.c imem.c main.c spi.c startup.s
